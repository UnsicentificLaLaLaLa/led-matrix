# Keil uVision project project.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: MM32G0001A1NC MindMotion
  pack: MindMotion.MM32G0001_DFP.0.0.2
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: APP_HELLO_WORLD BRD_FTHR_G0001
  c include: ..\device;..\device\CMSIS\Include;..;..\application;..\board;..\device\drivers
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  scatter file: ..\device\mdk\linker\mm32g0001a_flash.scf
  group application
    ../application/: main.c
  group board
    ../board/: board_init.c board_init.h clock_init.c clock_init.h pin_init.c pin_init.h
  group drivers
    ../device/drivers/: hal_adc.c hal_adc.h hal_common.h hal_crc.c hal_crc.h hal_exti.c hal_exti.h hal_flash.c hal_flash.h hal_gpio.c hal_gpio.h hal_i2c.c hal_i2c.h hal_iwdg.c hal_iwdg.h hal_power.c hal_power.h hal_pwr.c hal_pwr.h hal_rcc.c hal_rcc.h hal_spi.c hal_spi.h hal_syscfg.c hal_syscfg.h hal_tim.c hal_tim.h hal_usart.c hal_usart.h
  group device
    ../device/: hal_device_registers.h mm32g0001a.h mm32g0001a_features.h system_mm32g0001a.c system_mm32g0001a.h
    ../device/mdk/: startup_mm32g0001a.s
